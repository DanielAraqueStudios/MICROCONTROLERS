# Keil uVision project AAAAAA.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20020000,0x0005C000) IROM(0x08000000,0x00200000) IROM2(0x00200000,0x00200000) XRAM(0x2007C000,0x00004000) XRAM2(0x40024000,0x00001000) XRAM3(0x00000000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: AAAAAA +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT6: RAM 0x2007c000 size 0x4000
  memory RVCT7: RAM 0x40024000 size 0x1000
  memory RVCT8: RAM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x5c000
  group Source Group 1
    ./: main.cpp
software components: CMSIS:CORE 5.4.0, Device:Startup 1.2.5
